# Keil uVision project project.uvprojx, settings and files
target lwip (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\app;..\board;..\cmsis;..\lwip\src;..\lwip\src\api;..\lwip\src\arch;..\lwip\src\core;..\lwip\src\core\snmp;..\lwip\src\include;..\lwip\src\include\lwip;..\lwip\src\include\ipv4;..\lwip\src\include\ipv4\lwip;..\lwip\src\include\posix;..\lwip\src\include\posix\sys;..\lwip\src\netif;..\lwip\src\netif\ppp;..\stm_lib\inc;..\stm_lib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: main.c timers.c
  group cmsis
    ../cmsis/: startup_stm32f10x_hd.s core_cm3.c system_stm32f10x.c
  group stm-lib
    ../stm_lib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_cec.c stm32f10x_rcc.c
  group lwip
    ../lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip/src/arch/: ENC28J60.C SPI.C sys_arch.c
    ../lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
    ../lwip/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
